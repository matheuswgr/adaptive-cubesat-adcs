Commit message: working adaptive controller

File: cubesat-simulation/install/cubesat_description/share/cubesat_description/models/cubesat.urdf (robot description, URDF)
Before this commit: robot cubesat, 4 links, 3 joints
Joints:
- joint reaction_wheel_y_axis_shaft: axis 0 0 1 -> 0 0 -1
